## mach/configs/psx_defconfig
```kconfig
CONFIG_MACH=y
CONFIG_MACH_PSX=y
CONFIG_AUDIO_SDL=y
CONFIG_INPUT_SDL=y
CONFIG_VIDEO_SDL=y
```
